* NGSPICE file created from cntr_example.ext - technology: gf180mcuC

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__fill_2 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__fill_2 VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__filltie abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__filltie VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__fillcap_64 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__fillcap_64 VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__fillcap_4 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__fillcap_4 VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__clkinv_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__clkinv_1 I ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__antenna abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__antenna I VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__inv_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__inv_1 I ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__fillcap_32 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__fillcap_32 VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__nor2_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__nor2_1 A1 A2 ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__fill_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__fill_1 VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__oai22_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__oai22_1 A1 A2 B1 B2 ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__fillcap_8 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__fillcap_8 VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__fillcap_16 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__fillcap_16 VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__tiel abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__tiel ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__clkbuf_4 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__clkbuf_4 I Z VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__aoi21_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__aoi21_1 A1 A2 B ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__and4_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__and4_1 A1 A2 A3 A4 Z VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__xor2_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__xor2_1 A1 A2 Z VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__nand4_2 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__nand4_2 A1 A2 A3 A4 ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__oai21_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__oai21_1 A1 A2 B ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__nand3_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__nand3_1 A1 A2 A3 ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__aoi211_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__aoi211_1 A1 A2 B C ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__nand2_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__nand2_1 A1 A2 ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__or2_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__or2_1 A1 A2 Z VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__oai32_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__oai32_1 A1 A2 A3 B1 B2 ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__and3_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__and3_1 A1 A2 A3 Z VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__buf_2 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__buf_2 I Z VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__endcap abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__endcap VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__nand4_4 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__nand4_4 A1 A2 A3 A4 ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__nand2_2 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__nand2_2 A1 A2 ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__and2_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__and2_1 A1 A2 Z VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__dffrnq_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__dffrnq_1 D RN CLK Q VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__nand4_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__nand4_1 A1 A2 A3 A4 ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__clkbuf_2 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__clkbuf_2 I Z VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__and4_2 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__and4_2 A1 A2 A3 A4 Z VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__clkbuf_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__clkbuf_1 I Z VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__buf_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__buf_1 I Z VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__clkbuf_16 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__clkbuf_16 I Z VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__nor3_1 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__nor3_1 A1 A2 A3 ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__nor4_2 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__nor4_2 A1 A2 A3 A4 ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__nor3_2 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__nor3_2 A1 A2 A3 ZN VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__or4_2 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__or4_2 A1 A2 A3 A4 Z VDD VSS
.ends

* Black-box entry subcircuit for gf180mcu_fd_sc_mcu7t5v0__nor4_4 abstract view
.subckt gf180mcu_fd_sc_mcu7t5v0__nor4_4 A1 A2 A3 A4 ZN VDD VSS
.ends

.subckt cntr_example io_in[0] io_in[10] io_in[11] io_in[12] io_in[13] io_in[14] io_in[15]
+ io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21] io_in[22] io_in[23]
+ io_in[24] io_in[25] io_in[26] io_in[27] io_in[28] io_in[29] io_in[2] io_in[30] io_in[31]
+ io_in[32] io_in[33] io_in[34] io_in[35] io_in[36] io_in[37] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13]
+ io_out[14] io_out[15] io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20]
+ io_out[21] io_out[22] io_out[23] io_out[24] io_out[25] io_out[26] io_out[27] io_out[28]
+ io_out[29] io_out[2] io_out[30] io_out[31] io_out[32] io_out[33] io_out[34] io_out[35]
+ io_out[36] io_out[37] io_out[3] io_out[4] io_out[5] io_out[6] io_out[7] io_out[8]
+ io_out[9] vdd vss wb_clk_i wb_rst_i wbs_cyc_i wbs_stb_i wbs_we_i
XFILLER_54_258 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_199 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_188 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_177 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_27_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_52_29 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_432_ _250_ _003_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XANTENNA__429__I _250_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_501_ net54 _097_ vdd vss gf180mcu_fd_sc_mcu7t5v0__inv_1
XANTENNA_output37_I net37 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__329__A1 _146_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_294_ net39 _138_ vdd vss gf180mcu_fd_sc_mcu7t5v0__inv_1
XFILLER_42_84 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_42_40 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_41_453 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
X_363_ _146_ net8 _197_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_9_137 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_13_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_5_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_258 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_269 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_203 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_59_306 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_50_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__262__A3 _099_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_37_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_18_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__506__CLK clknet_2_1__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_41_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_415_ net65 _239_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_33_206 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_346_ _177_ _178_ _071_ _182_ _046_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai22_1
X_277_ _076_ _123_ _124_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_49_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_64_397 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_20_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_32_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_67_191 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_59_136 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_55_320 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA_input36_I wbs_we_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__529__CLK clknet_2_3__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_55_397 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_23_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__442__I _251_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_23_53 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_2_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_65_139 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_61_334 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_353 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_68 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_329_ _146_ net14 _168_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_9_66 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_14_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_43_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_6_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
Xcntr_example_72 io_out[35] vdd vss gf180mcu_fd_sc_mcu7t5v0__tiel
XFILLER_52_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_52_345 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_139 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__437__I _250_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_43_345 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_34_85 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_31_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_7_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_11_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XTAP_529 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_518 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_3_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_61_153 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__347__I net46 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_34_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__392__A2 net3 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_65_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_55_18 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_304 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__257__I net40 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_37_194 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_13_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA_output67_I net67 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_433 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_422 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_45_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_16_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_28_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_304 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_315 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_326 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_337 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_348 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_47_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_359 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_62_440 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__365__A2 _108_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_34_120 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_30_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_57_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_1_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_25_153 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_167 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__356__A2 _190_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_15_65 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xoutput42 net42 io_out[14] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XANTENNA__450__I _249_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
Xoutput64 net64 io_out[5] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
Xoutput53 net53 io_out[24] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_31_97 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_63_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_63_204 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_56_61 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__520__RN _014_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__292__A1 net52 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_241 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_44_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_31_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_8_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_12_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_39_223 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_189 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_178 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_167 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_156 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_145 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__511__RN _005_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_10_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_22_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_45_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_45_204 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_500_ net55 _096_ vdd vss gf180mcu_fd_sc_mcu7t5v0__inv_1
XANTENNA__445__I _251_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_53_281 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_431_ _250_ _002_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_45_259 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_26_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_362_ _190_ _195_ _192_ _196_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
X_293_ net66 net65 _065_ _103_ _137_ vdd vss gf180mcu_fd_sc_mcu7t5v0__and4_1
XFILLER_67_60 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__265__A1 _112_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_51_207 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_67_395 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_23_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_6_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__495__B2 _082_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__495__A1 _071_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_2_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__262__A4 _110_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_53_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_41_251 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_414_ _068_ _234_ _071_ _238_ _034_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai22_1
X_276_ _121_ _122_ _123_ vdd vss gf180mcu_fd_sc_mcu7t5v0__xor2_1
XFILLER_14_487 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_345_ _076_ net11 _181_ _182_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_5_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_64_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_64_332 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__410__A1 net65 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_32_240 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_32_284 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_32_295 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA_input29_I io_in[6] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_55_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_23_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_7_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_3_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_64_61 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_61_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_46_365 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_259_ net39 net38 net68 net67 _108_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand4_2
X_328_ _162_ _166_ _064_ _167_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_36_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_37_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_37_310 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xcntr_example_73 io_out[36] vdd vss gf180mcu_fd_sc_mcu7t5v0__tiel
XFILLER_64_173 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_52_313 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_40_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_20_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_55_140 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_43_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_43_313 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_43_302 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_28_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__453__I _252_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_519 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_50_85 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_19_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_34_313 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_22_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__519__CLK clknet_2_0__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_37_184 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_25_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__383__A3 _213_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_52_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_52_154 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_316 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_489 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_445 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_29_97 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_56_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__448__I _251_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_28_195 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_61_95 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_61_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_39_405 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_3_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_305 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_316 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_327 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_338 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_349 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_62_452 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_62_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_34_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_34_143 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_57_246 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA_input11_I io_in[19] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_40_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_31_54 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xoutput54 net54 io_out[25] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
Xoutput43 net43 io_out[15] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
Xoutput65 net65 io_out[6] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_63_227 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_48_257 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__292__A2 net49 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_297 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_275 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_16_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_31_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_168 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_157 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_146 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA_input3_I io_in[11] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_62_271 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_50_433 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_47_290 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_35_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_22_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_7_9 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_26_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_430_ _250_ _001_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_53_271 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_260 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_41_411 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_361_ _104_ _109_ _170_ _195_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai21_1
X_292_ net52 net49 _100_ _101_ _136_ vdd vss gf180mcu_fd_sc_mcu7t5v0__and4_1
XFILLER_26_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__461__I _249_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_42_64 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_67_72 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__265__A2 net60 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_3_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_44_271 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_17_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_44_293 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_8_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_66_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_59_319 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_67_352 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_238 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_227 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_19 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_42_219 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_10_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_23_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__281__I net57 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_12_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA_output42_I net42 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__456__I _252_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_46_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_413_ _076_ net30 _237_ _238_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_37_86 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_37_53 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_275_ net57 _099_ _110_ _122_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand3_1
XFILLER_41_263 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_344_ _178_ _180_ _172_ net36 _181_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi211_1
XFILLER_64_388 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__410__A2 _065_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_9_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_15_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_11_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_2_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_58_182 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_61_369 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_258_ net42 net41 _107_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
X_327_ net50 _156_ _166_ vdd vss gf180mcu_fd_sc_mcu7t5v0__or2_1
XFILLER_6_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xcntr_example_74 io_out[37] vdd vss gf180mcu_fd_sc_mcu7t5v0__tiel
XFILLER_29_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_56_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_49_160 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_37_333 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_18_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__386__A1 _202_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_7_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_59_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_509 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_50_97 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__310__A1 net53 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_3_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_46_174 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_61_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__377__B2 _177_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__377__A1 _188_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_57_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_57_406 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__301__A1 _076_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__368__A1 _064_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_37_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_40_339 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_0_402 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_20_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_457 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_16_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__359__A1 _146_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_43_177 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_43_155 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_43_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_43_111 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_61_85 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_39_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XTAP_306 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_328 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_339 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_34_133 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_34_100 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_19_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_40_136 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_103 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_25_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_40_169 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_21_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xoutput55 net55 io_out[26] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
Xoutput44 net44 io_out[16] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_48_214 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xoutput66 net66 io_out[7] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XANTENNA__459__I _252_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_56_96 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_48_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__509__CLK clknet_2_3__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_44_497 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_8_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_31_136 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_31_147 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__504__A1 net51 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__268__B1 _112_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_169 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_158 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_147 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_136 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_11_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_62_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_50_401 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_30_191 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_2_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_38_291 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_26_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_291_ _126_ _134_ _135_ _095_ _082_ _054_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_53_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_42_76 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_423 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_360_ _188_ _193_ _194_ _189_ _151_ _044_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_5_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_67_84 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__265__A3 _111_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_44_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_32_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_489_ _071_ _086_ _087_ _083_ _082_ _061_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_59_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_67_331 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_50_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_37_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_61_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_412_ _072_ _104_ _236_ _237_ vdd vss gf180mcu_fd_sc_mcu7t5v0__and3_1
XFILLER_14_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_26_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_53_86 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_275 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_274_ net58 _121_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_14_489 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_343_ net46 net45 net44 _179_ _180_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand4_2
XANTENNA__421__B net64 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_17_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_59_128 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_55_301 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_67_161 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_55_367 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_43_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_23_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_2_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_64_30 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_34_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_27 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_61_326 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_46_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_326_ _126_ _164_ _165_ _161_ _151_ _049_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
X_257_ net40 _106_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_6_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_10_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_153 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_52_337 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_37_323 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_60_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_16_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA_input34_I wbs_cyc_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_55_164 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_43_337 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__386__A2 net4 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_34_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_34_44 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_11_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_28_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__310__A2 _110_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_3_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_59_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_15_9 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_42_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
X_309_ _126_ _149_ _150_ _097_ _151_ _052_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_41_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_40_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_1_81 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_0_414 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__532__RN _026_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_56_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_43_123 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_66 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_29_77 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_8_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_24_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_6_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__523__RN _017_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_307 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_329 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_62_476 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_34_123 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_22_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__286__A1 _126_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__286__B2 _082_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_57_237 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_57_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__514__RN _008_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_15_57 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_25_134 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_31_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_31_89 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xoutput56 net56 io_out[27] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
Xoutput67 net67 io_out[8] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XANTENNA__277__A1 _076_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_299 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_233 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA_output65_I net65 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
Xoutput45 net45 io_out[17] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_63_229 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_56_53 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_16_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_31_104 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__268__B2 _082_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__268__A1 _071_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_148 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_137 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__504__A2 net50 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_47_292 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_47_281 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_39_204 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_159 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_50_457 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_30_170 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__259__A1 net39 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__295__I net38 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_281 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_270 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_290_ _073_ net20 _135_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_42_88 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_42_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_13_137 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__498__A1 _071_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__498__B2 _082_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_52 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_229 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_207 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_17_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_29_270 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_29_281 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_488_ _073_ net23 _087_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XANTENNA__489__B2 _082_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__489__A1 _071_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_387 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_67_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__413__A1 _076_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_35_240 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_50_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_58_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_490 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_53_76 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_411_ _234_ _235_ _236_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
X_342_ _104_ _109_ _179_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_14_479 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_273_ _071_ _118_ _119_ _120_ _082_ _057_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_5_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_45_9 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_64_368 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_52_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_49_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_32_210 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_32_287 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_67_173 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_55_324 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_55_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_48_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_64_53 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_48_87 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_346 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_324 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_46_313 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_302 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_97 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_61_338 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_325_ _146_ net15 _165_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_14_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__313__B1 _098_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_256_ net43 _105_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_6_497 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_10_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_64_110 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_49_162 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_49_140 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_52_349 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_52_305 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_37_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_25_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__304__B1 _096_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA_input27_I io_in[4] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_55_132 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_34_67 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_34_56 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_11_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_1_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_61_157 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_61_135 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_46_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_46_132 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__377__A3 _208_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_19_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_308_ _068_ _151_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
XFILLER_34_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_6_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_65_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_52_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_40_308 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_37_198 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_37_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_437 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_56_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_28_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_61_32 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_3_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XTAP_308 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_319 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_62_444 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_34_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_34_157 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_30_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__532__CLK clknet_2_2__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_38_441 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_25_157 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_40_138 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_40_116 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_40_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_15_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_25_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xoutput57 net57 io_out[28] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_5_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xoutput46 net46 io_out[18] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_31_46 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xoutput68 net68 io_out[9] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_63_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_56_10 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_48_238 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA_output58_I net58 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XPHY_130 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_16_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_29_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__491__I net37 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_8_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_12_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__268__A2 _115_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_149 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_138 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_39_227 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_22_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__350__B _064_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_58_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__259__A2 net38 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_41_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_38_260 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_3_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_230 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_17_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_487_ _078_ _085_ _064_ _086_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XANTENNA_input1_I io_in[0] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_4_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__413__A2 net30 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_35_252 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_23_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_50_299 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_10_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_12_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__511__D _037_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_2_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_58_388 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_491 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_480 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
X_272_ net60 _120_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_53_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_255 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_41_211 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_341_ net47 _178_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_26_241 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_410_ net65 _065_ _103_ _235_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand3_1
XFILLER_32_222 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_32_244 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_32_299 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__331__B2 _151_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__331__A1 _126_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_185 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_11_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__506__D _032_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_23_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_48_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__322__A1 net50 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_58_174 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA_output40_I net40 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_48_99 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__389__A1 _139_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_46_369 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_46_336 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_324_ _064_ _163_ _164_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
X_255_ net66 net65 _065_ _103_ _104_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand4_4
XANTENNA__313__B2 _151_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__313__A1 _126_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_37_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_52_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_45_380 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_20_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__304__A1 _126_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__304__B2 _082_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_55_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_55_100 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_18_25 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_28_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_50_89 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_50_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_42_361 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_34_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_307_ _146_ net18 _150_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_27_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_37_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_1_61 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_52_158 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_20_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_0_416 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_43_169 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_28_199 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_61_88 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_309 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_47_420 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_34_114 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_19_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_62_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_191 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_15_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_65_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__514__D _040_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_33_180 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xoutput58 net58 io_out[29] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
Xoutput47 net47 io_out[19] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_56_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_131 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_120 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_44_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_139 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_62_264 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_62_275 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_62_253 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_47_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_0 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XANTENNA__259__A3 net68 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__509__D _035_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_53_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_53_264 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_231 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_437 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_26_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__498__A3 _094_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_42_46 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_67_65 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_67_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_264 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_242 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_29_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__522__CLK clknet_2_3__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_44_297 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_275 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_486_ _083_ _084_ _085_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
XFILLER_12_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_59_5 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__489__A3 _087_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_8_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_67_323 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_55_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_35_231 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__361__B _170_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_31_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_481 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_46_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_470 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
X_271_ _073_ net24 _119_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_41_267 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_340_ _068_ _177_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
XFILLER_37_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_1_352 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_348 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_17_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_469_ _068_ _069_ _070_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_2
XFILLER_9_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_13_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_57_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_67_142 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_55_348 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_23_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__522__D _048_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__322__A2 _156_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_2_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_48_45 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_19_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_61_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_54_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_323_ _161_ _162_ _163_ vdd vss gf180mcu_fd_sc_mcu7t5v0__xor2_1
XFILLER_13_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_254_ net63 net64 _103_ vdd vss gf180mcu_fd_sc_mcu7t5v0__and2_1
XANTENNA_clkbuf_2_2__f_wb_clk_i_I clknet_0_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA_clkbuf_0_wb_clk_i_I wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_37_348 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_37_337 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_60_351 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__304__A2 _145_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__517__D _043_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_43_329 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_36_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_34_25 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_18_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_7_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_11_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__535__RN _029_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_50_79 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_3_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_46_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_61_148 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_373 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_306_ _072_ _148_ _149_ vdd vss gf180mcu_fd_sc_mcu7t5v0__and2_1
XFILLER_40_90 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_41_5 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__298__A1 net53 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_65_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_37_178 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_1_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_18_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__517__RN _011_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__289__A1 _076_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA_input32_I io_in[9] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_28_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_43_137 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_43_115 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_16_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_6_29 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__508__RN _002_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_62_424 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_59_281 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_34_104 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_30_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_53_424 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_25_126 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_21_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__530__D _056_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
Xoutput48 net48 io_out[1] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
Xoutput59 net59 io_out[2] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
Xoutput37 net37 io_out[0] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_0_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_56_240 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_132 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_121 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_110 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_8_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_12_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_21_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_50_449 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_47_295 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_262 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_424 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_1 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_30_140 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__259__A4 net67 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_53_210 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_273 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_26_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__416__A1 _065_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__525__D _051_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_41_449 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__352__B1 _183_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_1_501 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_67_99 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_67_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__407__A1 _202_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA_output63_I net63 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_44_254 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_485_ net48 net37 _084_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
XFILLER_32_91 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_58_324 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XTAP_493 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_482 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_471 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_53_35 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_37_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_26_221 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_270_ _076_ _117_ _118_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_41_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_22_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_49_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_468_ net35 _069_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_60_500 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_537_ _063_ _031_ clknet_2_1__leaf_wb_clk_i net63 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_27_91 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_32_202 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_399_ net67 _137_ _226_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
XANTENNA__331__A3 _168_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_63_371 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_63_360 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_28_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_23_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_58_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__512__CLK clknet_2_1__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_290 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_64_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_54_382 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_322_ net50 _156_ _162_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
XFILLER_6_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_10_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_253_ net52 net49 _100_ _101_ _102_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand4_1
XANTENNA__313__A3 _154_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_64_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_64_157 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_64_113 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_49_165 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_45_360 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__304__A3 _147_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_9_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__535__CLK clknet_2_0__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_55_168 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_51_341 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_34_59 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_34_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_34_48 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__533__D _059_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_59_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_46_168 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_46_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_46_124 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_61_127 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_305_ _097_ _142_ _148_ vdd vss gf180mcu_fd_sc_mcu7t5v0__xor2_1
XFILLER_42_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_30_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__298__A2 _136_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_65_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_1_85 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_429 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA_input25_I io_in[31] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__528__D _054_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_56_400 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_45_25 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_28_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_61_68 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_45_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_43_149 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_43_127 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_8_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_12_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_24_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_3_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_59_271 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_19_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_190 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_51_90 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_42_171 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_35_91 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_32_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_65_263 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_57_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_40_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_33_160 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_25_138 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_31_38 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xoutput49 net49 io_out[20] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
Xoutput38 net38 io_out[10] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_0_259 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_29_422 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_100 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_16_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_133 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_122 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_111 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XANTENNA__370__A1 _202_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_62_266 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_62_244 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_62_255 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_22_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__361__A1 _104_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_7_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_30_174 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_620 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_53_266 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_38_285 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_53_277 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__375__B _192_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_42_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_41_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_21_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__352__B2 _151_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__352__A1 _126_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_56 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA_output56_I net56 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__407__A2 net31 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_44_288 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_484_ net59 _083_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_17_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_274 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_8_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__343__A1 net46 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_369 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_35_211 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_50_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_23_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__334__A1 _170_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_58_303 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_494 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_483 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_472 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_461 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_450 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_53_25 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__536__D _062_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_41_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_41_203 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__325__A1 _146_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_5_137 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_1_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_1_332 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_64_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_81 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_398_ net68 _225_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_536_ _062_ _030_ clknet_2_0__leaf_wb_clk_i net62 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_43_91 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_9_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_467_ net34 _068_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_2
XANTENNA__316__A1 net51 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_177 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_63_383 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_63_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_55_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_48_380 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__307__A1 _146_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_23_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_280 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_291 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
X_321_ net51 _161_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_14_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_49_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_37_306 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xcntr_example_69 io_out[32] vdd vss gf180mcu_fd_sc_mcu7t5v0__tiel
XFILLER_64_103 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_37_339 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_33_501 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_60_342 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_54_90 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_519_ _045_ _013_ clknet_2_0__leaf_wb_clk_i net46 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_62_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_51_353 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_50_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_61_139 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_304_ _126_ _145_ _147_ _096_ _082_ _053_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_10_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_24_71 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_40_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__298__A3 _137_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_6_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_37_103 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_2_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_60_161 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_33_353 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_419 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_56_412 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA_input18_I io_in[25] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_61_36 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_59_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_3_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_34_139 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__525__CLK clknet_2_2__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_42_194 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_30_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_65_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_65_231 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_25_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_33_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xoutput39 net39 io_out[11] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_56_14 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_205 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_134 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_123 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_56_253 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XPHY_112 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_24_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_12_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__370__A2 net7 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_47_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_47_242 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_3 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_30_142 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_30_153 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__361__A2 _109_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_7_41 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_621 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_610 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_58_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__500__I net55 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_53_245 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_41_407 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_242 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_26_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA_output49_I net49 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_49_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_44_234 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_25_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_483_ _071_ _080_ _081_ _077_ _082_ _062_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_66_9 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_8_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__343__A2 net45 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_32_93 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_4_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_58_315 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_484 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_473 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_462 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_451 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_440 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__270__A1 _076_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_41_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_26_245 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__325__A2 net15 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_22_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_1_300 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_64_329 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_535_ _061_ _029_ clknet_2_0__leaf_wb_clk_i net59 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_17_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_397_ _188_ _223_ _224_ _139_ _177_ _037_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_43_81 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_43_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_466_ _064_ _066_ _067_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_32_226 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__316__A2 net50 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_9_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_48_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_23_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__307__A2 net18 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_48_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_2_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XTAP_270 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_281 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_292 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
X_320_ _126_ _159_ _160_ _155_ _151_ _050_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_10_487 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_13_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_37_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_1_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_518_ _044_ _012_ clknet_2_3__leaf_wb_clk_i net45 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_60_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_45_384 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_92 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_60_387 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_449_ _251_ _019_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XANTENNA__529__RN _023_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_55_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__473__A1 _073_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_28_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_3_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_59_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__464__A1 net62 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_42_343 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_303_ _146_ net19 _147_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XANTENNA__298__A4 _141_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_1_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_60_173 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_52_118 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_56_424 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_24_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_61_26 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_424 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_19_137 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_34_118 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_15_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_51_81 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_51_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_38_457 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_38_424 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_18_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_61_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__364__B1 _170_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_33_184 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_21_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_0_228 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__419__A1 _202_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_56_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA_input30_I io_in[7] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XPHY_135 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_124 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_113 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_52_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_102 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_21_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_67_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__299__B net55 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_47_254 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_221 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_43_493 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_4 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_30_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_30_187 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__346__B1 _071_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_600 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_7_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_622 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_611 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_38_232 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_235 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_202 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_41_419 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_34_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_26_29 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_67_25 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__515__CLK clknet_2_2__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_44_246 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_213 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_40_430 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_12_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_482_ _068_ _082_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
XANTENNA__343__A3 net44 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_349 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_57_91 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_35_235 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_16_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__334__A3 _104_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_31_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_441 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_430 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_485 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_474 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_452 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_37_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_22_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA_output61_I net61 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_534_ _060_ _028_ clknet_2_2__leaf_wb_clk_i net48 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_17_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_465_ net63 _065_ _066_ vdd vss gf180mcu_fd_sc_mcu7t5v0__xor2_1
XFILLER_27_83 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__261__A2 _104_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_396_ _202_ net2 _224_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XANTENNA__316__A3 _156_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_13_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_4_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_67_157 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__487__B _064_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_260 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_271 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_282 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_293 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_64_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_64_26 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_58_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_42_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_39_393 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_149 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_49_124 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_45_330 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_18_500 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_517_ _043_ _011_ clknet_2_2__leaf_wb_clk_i net44 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_60_355 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_60_344 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_448_ _251_ _018_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_379_ net40 _198_ _210_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
XFILLER_9_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_48_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_5_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_51_311 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_363 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_24_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_11_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_59_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_46_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__464__A2 net59 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_42_377 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_302_ _072_ _146_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
XFILLER_40_61 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_24_95 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_2_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_65_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_52_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_45_160 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_18_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__391__A1 _064_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_28_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_51_163 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_45_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_43_119 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__382__A1 _202_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_3_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_59_263 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_34_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_19_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_27_160 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__373__A1 net41 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_42_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_83 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_33_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__364__A1 _188_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__364__B2 _151_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__419__A2 net29 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA_input23_I io_in[2] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_56_211 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_56_16 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_16_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XPHY_125 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_114 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_103 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_8_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_12_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__355__A1 net44 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_47_200 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_62_258 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_62_236 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__291__B1 _095_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_47_277 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XPHY_5 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_15_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_62_92 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_30_166 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__346__A1 _177_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_623 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_612 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_601 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_7_65 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_30_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_38_244 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_53_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_21_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__337__A1 _146_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_200 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_17_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_29_277 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_481_ _073_ net26 _081_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_4_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_67_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_57_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__319__A1 _146_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__334__A4 _109_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_475 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_464 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_453 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_442 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_431 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_420 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_497 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_486 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_26_225 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_26_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_22_497 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA_output54_I net54 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_1_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_533_ _059_ _027_ clknet_2_0__leaf_wb_clk_i net37 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
X_464_ net62 net59 net48 net37 _065_ vdd vss gf180mcu_fd_sc_mcu7t5v0__and4_2
XFILLER_27_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_95 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_32_206 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__261__A3 _109_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_395_ _218_ _222_ _192_ _223_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_40_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_67_103 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_67_169 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_63_342 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_31_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_58_103 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_261 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_272 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_294 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_10_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_10_489 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_22_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__432__I _250_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_8_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_1_121 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_49_136 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_45_353 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__528__CLK clknet_2_3__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_60_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_60_312 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_378_ net41 _209_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_447_ _251_ _017_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_516_ _042_ _010_ clknet_2_1__leaf_wb_clk_i net43 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_45_364 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_13_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_342 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_59_423 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__464__A3 net48 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_54_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_301_ _076_ _144_ _145_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_42_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_42_301 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_24_74 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_30_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__427__I net33 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_34_9 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_2_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_65_92 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_60_120 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_45_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_37_139 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_33_345 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_1_89 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_21_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_60_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_56_404 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_45_29 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_36_194 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_183 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_150 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_12_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_24_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_59_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_55_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_27_194 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__373__A2 net40 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_42_175 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_153 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_51_94 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_65_245 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_65_201 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_437 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_33_164 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_18_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA_input16_I io_in[23] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_56_234 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_56_223 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_37_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_126 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_115 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_52_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_104 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XANTENNA__440__I _251_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_4_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_20_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__291__B2 _082_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__291__A1 _126_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_47_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_6 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_28_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_30_145 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_624 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_613 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_602 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA_input8_I io_in[16] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__510__RN _004_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_53_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__282__A1 _099_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_289 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_256 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_201 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_19_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_23_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__337__A2 net13 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_34_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__273__A1 _071_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__273__B2 _082_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_29_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_234 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_52_270 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_44_226 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_12_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_480_ _076_ _079_ _080_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XANTENNA__435__I _250_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_52_281 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_487 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_8_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_32_85 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_67_307 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__264__A1 net60 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_35_237 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_35_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__319__A2 net16 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_43_281 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_43_270 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_35_248 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_16_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_31_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_498 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_487 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_476 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_465 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_454 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_443 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_432 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_410 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__255__A1 net66 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_34_281 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__494__A1 _073_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA_output47_I net47 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_17_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_532_ _058_ _026_ clknet_2_2__leaf_wb_clk_i net61 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
X_394_ _139_ _217_ _222_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
XFILLER_43_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_43_51 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_463_ net36 _064_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
XFILLER_9_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_13_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_32_218 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_64_9 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_40_295 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__485__A1 net48 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_4_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_31_251 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_64_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_54_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_48_29 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_240 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_251 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_262 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_273 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_284 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_295 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_10_479 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_1_133 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_1_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_515_ _041_ _009_ clknet_2_2__leaf_wb_clk_i net42 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
X_446_ _251_ _016_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_54_94 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_377_ _188_ _207_ _208_ _204_ _177_ _041_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_63_151 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_51_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_36_387 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_24_505 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__464__A4 net37 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_27_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_300_ _132_ _143_ _144_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_10_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__443__I _251_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_6_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_37_107 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_2_497 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_60_165 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_33_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_18_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_429_ _250_ _000_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XANTENNA__353__I _070_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_53_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
Xinput1 io_in[0] net1 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_61_18 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__263__I net61 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__518__CLK clknet_2_3__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_47_416 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__438__I _250_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_42_121 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_15_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_27_184 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_51_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_42_187 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_2_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_65_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_65_257 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_61_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_33_198 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_33_132 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__364__A3 _197_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_209 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_116 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_56_246 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_127 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_52_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_24_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_28_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_43_441 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_7 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_30_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_625 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_614 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_603 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__282__A2 _110_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_268 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_16_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_34_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__273__A2 _118_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_44_205 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_52_260 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_40_422 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_25_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__451__I _252_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_40_455 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_12_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_48_500 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_4_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_57_83 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__264__A2 _111_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_16_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_31_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_400 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_488 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_477 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_466 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_455 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_444 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_433 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_422 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_411 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__255__A2 net65 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_66_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_1_348 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_531_ _057_ _025_ clknet_2_3__leaf_wb_clk_i net60 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XANTENNA__446__I _251_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_462_ _249_ _031_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_43_63 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_43_30 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_393_ _188_ _220_ _221_ _138_ _177_ _038_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_13_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_36_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__485__A2 net37 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_381 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_23_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_31_241 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_58_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_230 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_241 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_171 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_352 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_252 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_263 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_274 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_285 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_296 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_13_66 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_64_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_60_303 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_54_84 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_514_ _040_ _008_ clknet_2_1__leaf_wb_clk_i net41 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_45_388 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_45_333 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_45_311 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_38_96 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_38_85 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_445_ _251_ _015_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_376_ _202_ net6 _208_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_9_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_48_5 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_48_182 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_63_163 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_63_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_51_325 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_51_303 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__394__A1 _139_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_59_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_46_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_39_160 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_42_369 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_347 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_86 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_40_53 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_65_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_49_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_1_25 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_1_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_428_ _249_ _250_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
XFILLER_60_155 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_45_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__376__A1 _202_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_359_ _146_ net9 _194_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XANTENNA__300__A1 _132_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_46_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_56_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_36_196 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_174 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_130 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
Xinput2 io_in[10] net2 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_24_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_28_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_51_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__367__A1 _105_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_10_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_59_277 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_59_211 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__358__A1 _184_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_35_31 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_30_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__454__I _252_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_51_85 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_33_111 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_61_464 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__349__A1 _183_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_33_188 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_33_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_56_225 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_56_19 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_29_406 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_29_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XPHY_128 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_117 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_106 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_52_497 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__274__I net58 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_21_66 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__449__I _251_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_47_258 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_269 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_225 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_62_51 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_55_291 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_8 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_11_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_15_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__503__A1 _095_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_7_57 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_7_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_615 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_604 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_38_225 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_239 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_206 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_38_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_61_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__508__CLK clknet_2_0__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_1_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA_input21_I io_in[28] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_52_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_40_434 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_489 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_57_62 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_57_95 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_57_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_43_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_423 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_412 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_401 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_489 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_478 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_467 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_445 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_434 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__255__A3 _065_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_34_272 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_34_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_22_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_57_397 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_57_353 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_530_ _056_ _024_ clknet_2_0__leaf_wb_clk_i net58 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
X_461_ _249_ _030_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XANTENNA__462__I _249_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_43_97 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_275 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_40_220 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_392_ _202_ net3 _221_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_25_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_4_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_67_139 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_334 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_51_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_16_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_31_231 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__372__I net42 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_8_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_31_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XTAP_220 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_231 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_242 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_253 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_264 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_275 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_161 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_64_19 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_54_334 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_320 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_297 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_49_128 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_45_301 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA_output52_I net52 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__457__I _252_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_60_337 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_444_ _251_ _014_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_513_ _039_ _007_ clknet_2_1__leaf_wb_clk_i net40 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XANTENNA__406__B _192_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_375_ _199_ _206_ _192_ _207_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_9_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_13_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_5_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_323 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_334 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_67_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_67_481 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_337 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_39_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_15_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_50_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_24_99 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_49_41 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_40_65 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_76 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_6_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_65_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__376__A2 net6 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_358_ _184_ _191_ _192_ _193_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_18_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_427_ net33 _249_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_1
X_289_ _076_ _133_ _134_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_39_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_64_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_49_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_36_186 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_36_142 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xinput3 io_in[11] net3 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_51_167 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__367__A2 _199_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_32_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_3_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__531__RN _025_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_47_407 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_19_66 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_27_131 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_42_167 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_145 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_98 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_87 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_43 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_27_197 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__470__I _070_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__522__RN _016_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_65_237 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_65_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_46_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__349__A2 _184_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_14_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__513__RN _007_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__285__A1 _073_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XPHY_129 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_64_281 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_118 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_107 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_12_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_62_218 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_47_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_9 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_62_96 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_616 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_605 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__503__A2 _096_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_7_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__267__A1 _073_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_204 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_292 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_21_137 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__258__A1 net42 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA_input14_I io_in[21] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_37_292 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_37_281 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_16_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_25_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_29_204 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_226 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_479 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_40_402 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_8_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__497__A1 net1 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_4_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_57_30 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_35_207 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__421__A1 net63 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_7_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__488__A1 _073_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_457 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_446 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_435 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_424 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_413 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_402 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XTAP_479 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_468 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA_input6_I io_in[14] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_21_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_60_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__403__A1 _188_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__403__B2 _177_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_460_ _252_ _029_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_43_32 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_391_ _064_ _219_ _220_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_27_66 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_27_77 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_99 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_43_87 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_43_65 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_40_287 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_9_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_4_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_67_107 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_48_365 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_48_376 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_48_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_379 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_63_368 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_31_210 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_210 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_221 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_232 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_254 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_265 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_276 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_287 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_298 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_346 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_54_313 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_54_302 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__397__B1 _139_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_39_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_22_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA_output45_I net45 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_60_316 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_443_ _251_ _013_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_512_ _038_ _006_ clknet_2_1__leaf_wb_clk_i net39 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_45_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_374_ _204_ _205_ _206_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
XFILLER_33_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_165 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_379 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_36_346 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_302 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_24_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_51_349 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_54_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_24_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_24_89 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_40_99 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_2_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_65_96 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_58_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_45_121 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_60_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_357_ net36 _192_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
XFILLER_41_393 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_426_ _070_ _246_ _247_ _248_ _177_ _032_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
X_288_ net56 _132_ _133_ vdd vss gf180mcu_fd_sc_mcu7t5v0__xor2_1
XFILLER_5_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_56_408 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__378__I net41 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
Xinput4 io_in[12] net4 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_64_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_51_102 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_32_382 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_67_290 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_55_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_42_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_42_135 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_51_98 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_51_87 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_51_76 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_65_205 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_65_249 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_46_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_33_168 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_33_113 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_18_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_61_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_409_ net66 _234_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_51_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__285__A2 net21 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_64_271 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_119 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_37_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_24_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_4_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_20_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__531__CLK clknet_2_3__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_43_477 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_28_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_62_86 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_43_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_30_149 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_617 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_606 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__503__A3 _097_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_238 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_282 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_19_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__258__A2 net41 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_29_238 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_52_285 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_436 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_12_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_25_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_32_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__497__A2 _073_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__476__I net36 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__421__A2 _065_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_31_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__488__A2 net23 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_469 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_458 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_447 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_436 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_414 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_403 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__412__A2 _104_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_14_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_57_322 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_57_333 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_17_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_390_ _138_ _218_ _219_ vdd vss gf180mcu_fd_sc_mcu7t5v0__xor2_1
XFILLER_40_244 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_13_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_40_255 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_4_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_48_311 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_48_388 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_384 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_8_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_58_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_39_344 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_200 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_211 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_222 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_233 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_244 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_255 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_266 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_277 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_288 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_299 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__397__A1 _188_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__397__B2 _177_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_1_137 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_57_130 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_511_ _037_ _005_ clknet_2_1__leaf_wb_clk_i net38 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_45_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA_output38_I net38 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_60_339 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_442_ _251_ _012_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XANTENNA__388__A1 net68 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_373_ net41 net40 _198_ _205_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand3_1
XFILLER_9_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__312__A1 _146_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_5_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_0_192 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_63_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_155 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_48_174 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__379__A1 net40 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_59_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_5_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__303__A1 _146_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_472 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_54_166 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_42_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_67 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_40_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_10_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_49_65 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_1_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_60_103 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_45_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__484__I net59 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_18_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_287_ net55 net54 net53 _110_ _132_ vdd vss gf180mcu_fd_sc_mcu7t5v0__and4_1
X_356_ _189_ _190_ _191_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
X_425_ net64 _248_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
Xinput5 io_in[13] net5 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_36_133 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_100 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_51_147 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_36_166 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_32_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_10_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_59_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_55_420 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_67 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_27_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_27_166 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_23_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_30_309 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_2_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_46_431 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_18_9 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_61_423 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_408_ _188_ _232_ _233_ _230_ _177_ _035_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_33_147 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_33_136 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_339_ _126_ _174_ _175_ _176_ _151_ _047_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_44_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_64_261 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_56_228 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_24_103 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_109 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_52_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_55_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_43_445 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_7_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XTAP_618 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_607 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__503__A4 _098_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_46_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_61_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_34_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xinput30 io_in[7] net30 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_52_275 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_209 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_37_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_40_459 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_20_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA_output68_I net68 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_63_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_57_98 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_28_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_43_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_43_220 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_16_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_459 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_448 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_437 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_426 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_415 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_404 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_54_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__412__A3 _236_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_19_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__521__CLK clknet_2_3__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_57_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_45_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xclkbuf_2_3__f_wb_clk_i clknet_0_wb_clk_i clknet_2_3__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_25_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_21_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_4_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_0_352 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_48_367 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_8_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_31_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_201 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_223 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_175 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_312 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_234 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_245 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_256 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_267 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_278 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_289 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_27_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_62_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__512__D _038_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_441_ _251_ _011_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_510_ _036_ _004_ clknet_2_2__leaf_wb_clk_i net68 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_60_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__388__A2 net67 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_89 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_372_ net42 _204_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_13_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_5_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_63_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_0_171 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_51_307 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_36_359 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__303__A2 net19 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_451 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__507__D _033_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_24_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_6_5 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA_output50_I net50 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__534__RN _028_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_1_29 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_58_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_45_112 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_41_351 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_424_ _202_ net28 _247_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_33_329 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_26_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_286_ _126_ _130_ _131_ _127_ _082_ _055_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
X_355_ net44 _179_ _190_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
XANTENNA__525__RN _019_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__297__A1 _138_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
Xinput6 io_in[14] net6 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_24_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_32_362 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__288__A1 net56 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_59_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__516__RN _010_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_51_78 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_51_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__279__A1 _071_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__279__B2 _082_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_4_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_58_270 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_18_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_90 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
X_407_ _202_ net31 _233_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
X_338_ net49 _176_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_25_90 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_269_ net60 _111_ _117_ vdd vss gf180mcu_fd_sc_mcu7t5v0__xor2_1
XFILLER_37_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_20_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__520__D _046_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_47_229 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_55_273 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_43_424 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_15_137 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_28_487 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__264__B _112_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_11_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_619 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_608 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__424__A1 _202_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_19_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xinput31 io_in[8] net31 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
Xinput20 io_in[27] net20 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
Xclkbuf_2_2__f_wb_clk_i clknet_0_wb_clk_i clknet_2_2__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_29_218 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_52_254 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_52_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_16_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__515__D _041_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_32_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_405 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_7_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_3_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_449 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_438 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_427 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_416 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_30_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_57_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_57_324 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA_input12_I io_in[1] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_43_68 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_43_35 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_40_224 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_202 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_48_324 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_375 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_63_338 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_16_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_31_202 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_12_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_202 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_213 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_224 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_235 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_246 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_257 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_338 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_54_305 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_39_324 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_302 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA_input4_I io_in[12] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_268 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__362__B _192_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_18_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_440_ _251_ _010_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_54_45 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_54_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_53_360 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__388__A3 _137_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_45_305 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_371_ _188_ _201_ _203_ _105_ _151_ _042_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_13_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_48_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__511__CLK clknet_2_1__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_194 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_168 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_382 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_67_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_8_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_54_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_54_124 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_54_102 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_35_360 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_50_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_24_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__523__D _049_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__534__CLK clknet_2_2__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_58_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA_output43_I net43 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_65_99 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_60_116 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_60_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_45_168 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_363 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_354_ net45 _189_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_423_ _240_ _245_ _192_ _246_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_60_9 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_285_ _073_ net21 _131_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XANTENNA__297__A2 _139_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_5_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_1_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_433 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_49_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
Xinput7 io_in[15] net7 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_36_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_36_146 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_124 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_51_138 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_20_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_32_330 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__288__A2 _132_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_282 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_55_411 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__518__D _044_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_55_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_42_149 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_127 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_7_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_61_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_46_455 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_46_400 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_33_116 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_18_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_406_ _226_ _231_ _192_ _232_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XPHY_91 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_171 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XPHY_80 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
X_337_ _146_ net13 _175_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_33_138 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_14_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_268_ _071_ _115_ _116_ _112_ _082_ _058_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_56_219 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xclkbuf_2_1__f_wb_clk_i clknet_0_wb_clk_i clknet_2_1__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_64_285 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_64_241 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_37_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_24_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_32_171 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_47_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_62_45 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_62_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_30_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XTAP_609 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_38_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_61_200 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_46_296 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_46_274 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__424__A2 net28 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_19_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xinput32 io_in[9] net32 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
Xinput21 io_in[28] net21 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
Xinput10 io_in[18] net10 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XANTENNA__360__B2 _151_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__360__A1 _188_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_6_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_37_241 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_25_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_40_439 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_40_406 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_12_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_32_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__531__D _057_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__351__A1 _146_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_4_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_43_266 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_11_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_31_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XTAP_439 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_417 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_406 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__342__A1 _104_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_66_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_14_5 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__333__A1 net47 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_25_200 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__526__D _052_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_13_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__324__A1 _064_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_48_303 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_387 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_31_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__315__A1 net49 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_66_100 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_203 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_214 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_225 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_236 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_258 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_269 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_12_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_22_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_1_129 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_57_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_38_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_370_ _202_ net7 _203_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_63_147 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_184 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_499_ net56 _095_ vdd vss gf180mcu_fd_sc_mcu7t5v0__inv_1
XFILLER_5_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_67_464 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_67_431 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_50_397 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_49_57 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_65_89 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_45_125 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_284_ _076_ _129_ _130_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_41_331 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_353_ _070_ _188_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
X_422_ _244_ _245_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_53_9 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__297__A3 _107_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_64_401 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xclkbuf_2_0__f_wb_clk_i clknet_0_wb_clk_i clknet_2_0__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_39_90 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xinput8 io_in[16] net8 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_17_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_67_294 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA_clkbuf_2_1__f_wb_clk_i_I clknet_0_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_35_191 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_35_59 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_35_26 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__534__D _060_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_58_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_61_415 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_267_ _073_ net25 _116_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
X_405_ _230_ _104_ _231_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
XPHY_92 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_81 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_25_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_336_ _064_ _173_ _174_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_44_5 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_41_91 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_49_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_37_423 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_275 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_253 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__524__CLK clknet_2_0__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_20_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA_input35_I wbs_stb_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__529__D _055_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_55_297 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_55_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_55_242 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_55_253 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_55_231 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_28_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_28_489 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_51_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_61_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_46_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_14_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_319_ _146_ net16 _160_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
Xinput11 io_in[19] net11 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
Xinput33 wb_rst_i net33 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
Xinput22 io_in[29] net22 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_57_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_37_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_52_289 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_33_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__381__B _192_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__351__A2 net10 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_43_278 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_43_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_28_242 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__342__A2 _109_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_429 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_39_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_418 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_407 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_19_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_15_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__333__A2 net46 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_30_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_43_26 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_25_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_43_59 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_40_259 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_4_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA_output66_I net66 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_63_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_56_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_48_315 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__260__A1 _105_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_31_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_12_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_204 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_226 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_237 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_248 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_259 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_167 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__537__D _063_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_9_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_13_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_5_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__537__RN _031_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_174 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__481__A1 _073_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_44_362 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_370 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_498_ _071_ _093_ _094_ _089_ _082_ _059_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_67_476 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_67_454 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_50_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_35_340 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__519__RN _013_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_49_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_590 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_58_454 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_18_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_421_ net63 _065_ net64 _244_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
X_283_ _127_ _128_ _129_ vdd vss gf180mcu_fd_sc_mcu7t5v0__xor2_1
X_352_ _126_ _186_ _187_ _183_ _151_ _045_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_41_310 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_49_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xinput9 io_in[17] net9 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_36_104 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_457 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_32_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_32_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_67_262 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_55_424 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_50_151 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_23_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_2_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_58_295 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_404_ net67 _230_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XPHY_82 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_71 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_33_107 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_14_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XPHY_60 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
X_266_ net36 _113_ _114_ _115_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor3_1
XPHY_93 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_335_ net49 _172_ _173_ vdd vss gf180mcu_fd_sc_mcu7t5v0__xor2_1
XFILLER_60_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__418__A1 _235_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA_input28_I io_in[5] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_46_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_28_479 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_11_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_2_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_11_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_66_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_61_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_42_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__308__I _068_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
Xinput23 io_in[2] net23 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
Xinput12 io_in[1] net12 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XANTENNA__360__A3 _194_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_318_ _064_ _158_ _159_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
Xinput34 wbs_cyc_i net34 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_35_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_52_268 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_20_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_48_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_28_210 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_43_224 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_24_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__514__CLK clknet_2_1__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_419 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_408 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_34_246 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_34_268 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_30_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__333__A3 net45 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_57_349 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__501__I net54 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_25_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__309__B1 _097_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_21_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__537__CLK clknet_2_1__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_367 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_0_356 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_44_500 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA_output59_I net59 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_12_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__315__A3 _137_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_205 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_8_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_66_124 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__321__I net51 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_39_316 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_216 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_227 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_238 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_249 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_62_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_50_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_47_360 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_47_371 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_30_293 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_54_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_38_360 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA_input10_I io_in[18] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_36_308 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_0_142 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_197 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__481__A2 net26 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_63_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_48_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_28_93 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_32_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_497_ net1 _073_ _094_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_67_422 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_39_168 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA_input2_I io_in[10] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_62_182 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_352 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_591 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_580 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_65_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_60_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_53_160 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_45_116 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_420_ _070_ _242_ _243_ _239_ _177_ _033_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_41_322 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_351_ _146_ net10 _187_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_26_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_282_ _099_ _110_ _128_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
XFILLER_5_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_30_94 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_49_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_39_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_32_311 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_32_366 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_65_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__390__A1 _138_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_241 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_67_296 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_42_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_35_39 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_28 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_58_230 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_46_447 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA_output41_I net41 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_18_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_61_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
X_403_ _188_ _228_ _229_ _225_ _177_ _036_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XPHY_94 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_83 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_72 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_50 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_25_94 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
X_334_ _170_ _171_ _104_ _109_ _172_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor4_2
XPHY_61 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
X_265_ _112_ net60 _111_ _114_ vdd vss gf180mcu_fd_sc_mcu7t5v0__and3_1
XFILLER_2_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_66_90 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_64_211 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_45_480 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_37_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_37_403 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_24_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__363__A1 _146_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_20_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_32_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_32_163 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_55_233 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_62_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__395__B _192_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_43_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_23_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_46_233 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_222 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_19_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_317_ _155_ _157_ _158_ vdd vss gf180mcu_fd_sc_mcu7t5v0__xor2_1
Xinput13 io_in[20] net13 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XANTENNA__345__A1 _076_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
Xinput24 io_in[30] net24 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
Xinput35 wbs_stb_i net35 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_28_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_52_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_37_299 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_37_277 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_25_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__336__A1 _064_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_57_26 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_51_280 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__409__I net66 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_11_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__327__A1 net50 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_7_137 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_3_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_59_391 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XTAP_409 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_47_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_80 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__318__A1 _064_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_65_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_40_228 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_40_206 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__309__A1 _126_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__309__B2 _151_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_48_328 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_0_379 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__260__A3 _107_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_16_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_17_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_31_206 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_31_239 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_33_61 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__315__A4 _141_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_206 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_217 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_228 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_239 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_58_91 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_39_328 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__493__B _064_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_30_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_30_261 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__475__B1 _068_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_54_49 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_53_331 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_45_309 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_21_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_48_103 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_44_93 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_496_ _089_ _076_ _093_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_67_6 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_8_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_12_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_67_401 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_4_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__332__I net44 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_478 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_67_489 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_10_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__527__CLK clknet_2_3__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_50_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_592 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_581 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_570 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
X_350_ _180_ _185_ _064_ _186_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
X_281_ net57 _127_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_41_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_5_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_55_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_128 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_1_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_55_92 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_20_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_479_ _077_ _078_ _079_ vdd vss gf180mcu_fd_sc_mcu7t5v0__xor2_1
XFILLER_32_334 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_58_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_67_231 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_63_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_35_18 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_27_139 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_50_175 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_11_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_58_275 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_459 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_404 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_402_ _202_ net32 _229_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
X_264_ net60 _111_ _112_ _113_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XPHY_95 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_84 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_153 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_14_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_40 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_25_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_51 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_26_183 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_26_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_333_ net47 net46 net45 _171_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand3_1
XPHY_62 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_83 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_6_500 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_2_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_267 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_49_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_32_131 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_60_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_32_175 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_55_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_62_49 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_3_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_11_53 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__430__I _250_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_61_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__290__A1 _073_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_46_278 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_27_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xinput25 io_in[31] net25 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
Xinput14 io_in[21] net14 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_42_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_316_ net51 net50 _156_ _157_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand3_1
Xinput36 wbs_we_i net36 vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_1
XANTENNA__345__A2 net11 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__340__I _068_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_6_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_10_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_37_245 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_37_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_20_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA_input33_I wb_rst_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_43_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_24_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__425__I net64 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__327__A2 _156_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_66_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_19_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_92 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_63_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_57_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_40_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_57_329 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_25_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__254__A1 net63 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_43_18 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__309__A2 _149_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_21_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_4_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_48_307 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__260__A4 _108_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_33_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_3_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_207 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_218 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_229 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_104 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_66_126 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_62_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_58_81 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_47_340 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_30_273 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__475__A1 _067_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_53_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_53_310 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_5_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA_output64_I net64 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__466__A1 _064_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_44_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_0_177 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_495_ _071_ _091_ _092_ _088_ _082_ _060_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_32_505 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_60_93 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_67_457 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_39_126 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_5_66 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_62_173 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_50_313 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_47_192 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__393__B1 _138_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_593 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_582 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_571 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_560 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_58_446 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_45_118 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_45_107 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_26_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_41_379 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_41_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_41_335 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_280_ _070_ _126_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
XANTENNA__433__I _250_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_30_85 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_449 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_39_94 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_17_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_192 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_44_195 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_478_ net59 net48 net37 _078_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand3_1
XFILLER_32_346 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_55_405 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_50_143 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_140 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_23_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__428__I _249_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_54_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_401_ _217_ _227_ _192_ _228_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_46_427 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_390 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XPHY_30 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
X_263_ net61 _112_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XPHY_96 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_85 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_121 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_74 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_41 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_52 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
X_332_ net44 _170_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XPHY_63 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_95 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_41_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__517__CLK clknet_2_2__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_1_294 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_1_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_64_235 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_60_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__338__I net49 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_9_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_32_187 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_55_257 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_55_246 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_51_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_11_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__290__A2 net20 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_42_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_42_452 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xinput15 io_in[22] net15 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_52_94 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_315_ net49 _101_ _137_ _141_ _156_ vdd vss gf180mcu_fd_sc_mcu7t5v0__and4_1
Xinput26 io_in[3] net26 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_14_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_37_202 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_18_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_33_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_20_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_57_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA_input26_I io_in[3] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_43_227 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_24_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_28_246 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_51_293 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__441__I _251_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_47_83 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_19_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_42_282 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_15_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_6_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_33_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__254__A2 net64 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_33_293 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_21_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_0_359 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_56_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__436__I _250_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_39_308 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_219 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_7_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_57_138 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__475__A2 _071_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_26_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_65_160 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__256__I net43 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_13_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_48_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_167 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA_output57_I net57 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_56_171 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_44_366 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_44_344 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_333 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_311 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_374 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
X_494_ _073_ net12 _092_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_4_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_67_447 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_54_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__393__A1 _188_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__393__B2 _177_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_561 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_58_414 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XTAP_550 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_594 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_583 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_572 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_58_458 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_41_303 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__384__A1 _104_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_14_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_5_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_49_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_39_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_39_62 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_1_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_32_325 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_65_5 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__375__A1 _199_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_477_ net62 _077_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_67_299 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_67_277 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_67_266 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_67_244 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_55_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__366__A1 net42 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_35_152 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_58_266 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_391 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_380 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
X_400_ _225_ _226_ _227_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
XFILLER_46_417 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_331_ _126_ _167_ _168_ _169_ _151_ _048_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XPHY_20 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_14_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_31 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_18_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XPHY_42 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_26_152 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_53 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_64 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XANTENNA__444__I _251_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XPHY_97 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
X_262_ net58 net57 _099_ _110_ _111_ vdd vss gf180mcu_fd_sc_mcu7t5v0__and4_1
XPHY_86 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_63 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_75 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_25_86 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_37_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_529_ _055_ _023_ clknet_2_3__leaf_wb_clk_i net57 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_60_497 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__348__A1 net45 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_17_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_32_111 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_63_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__354__I net45 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_63_280 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__339__B2 _151_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__339__A1 _126_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_23_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__439__I _249_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_46_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_46_225 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_214 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_19_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_314_ net52 _155_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_36_85 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_96 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xinput16 io_in[23] net16 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
Xinput27 io_in[4] net27 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_6_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_60_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__507__CLK clknet_2_1__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_51_272 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_291 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA_input19_I io_in[26] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_22_32 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_3_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_47_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_42_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_8_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_30_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_26_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
Xclkbuf_0_wb_clk_i wb_clk_i clknet_0_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_33_272 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_33_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_349 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_12_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_24_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_33_53 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__452__I _252_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_59_191 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__401__B _192_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_209 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_62_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_50_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_353 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_375 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_47_342 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_15_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_30_253 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__475__A3 _074_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_53_323 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__272__I net60 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_21_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_0_135 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__447__I _251_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_493_ _084_ _090_ _064_ _091_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_44_85 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_4_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_67_426 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_62_186 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__357__I net36 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_23_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_584 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_573 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_562 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_551 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_540 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_595 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_45_109 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_26_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_41_326 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__384__A2 _108_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_14_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_30_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_30_87 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_30_98 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_1_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_57_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_55_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_55_62 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_44_175 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_476_ net36 _076_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
XFILLER_40_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_67_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_50_167 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_50_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__366__A2 net41 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_58_234 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__530__RN _024_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_46_407 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_381 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_370 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_98 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_87 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
X_330_ net50 _169_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_39_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_76 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_10 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_32 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_43 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_54 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_65 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_53 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_22_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
X_261_ _102_ _104_ _109_ _110_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor3_2
XANTENNA__460__I _252_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_49_201 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__293__A1 net66 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_528_ _054_ _022_ clknet_2_3__leaf_wb_clk_i net56 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
X_459_ _252_ _028_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XANTENNA__348__A2 net44 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_20_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_32_145 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_56_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_55_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_55_204 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__284__A1 _076_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__512__RN _006_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_55_248 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_51_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_36_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_23_123 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__280__I _070_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_46_237 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__275__A1 net57 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__455__I _252_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_54_270 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_313_ _126_ _153_ _154_ _098_ _151_ _051_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_42_432 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_14_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xinput17 io_in[24] net17 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
Xinput28 io_in[5] net28 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XANTENNA__266__A1 net36 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_37_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_33_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_18_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_60_295 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_57_19 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_51_262 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_11_137 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_59_373 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_59_351 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__420__A1 _070_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_15_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_19_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_63_84 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_63_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_42_273 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__420__B2 _177_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_65_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_19_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__411__A1 _234_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA_input31_I io_in[8] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__478__A1 net59 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__402__A1 _202_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_56_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_33_65 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__469__A1 _068_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_3_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_30_265 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_65_162 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_53_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_53_302 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_38_365 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_103 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_44_335 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_492_ _088_ _089_ _090_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
XFILLER_32_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_44_97 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__463__I net36 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_8_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_12_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_62_132 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_35_324 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_35_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_596 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_585 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_574 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_563 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_552 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_541 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_530 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_38_195 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_14_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA_output62_I net62 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_30_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_55_30 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__458__I _252_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_39_86 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_55_96 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_475_ _067_ _071_ _074_ _068_ _075_ _063_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_17_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_32_327 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_4_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_67_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_48_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_50_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__366__A3 net40 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_58_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_393 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_382 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_360 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_371 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XPHY_99 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_88 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_157 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_146 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_77 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
X_260_ _105_ _106_ _107_ _108_ _109_ vdd vss gf180mcu_fd_sc_mcu7t5v0__or4_2
XPHY_11 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_22 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_44 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_25_66 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_26_187 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_26_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_55 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_66 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_87 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_2_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_1_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__293__A2 net65 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_527_ _053_ _021_ clknet_2_3__leaf_wb_clk_i net55 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_64_227 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_49_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_45_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_37_419 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_32_102 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_458_ _252_ _027_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_389_ _139_ _217_ _218_ vdd vss gf180mcu_fd_sc_mcu7t5v0__or2_1
XFILLER_40_190 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_32_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_49_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_55_238 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_51_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_36_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__275__A2 _099_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_61_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_190 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_27_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_312_ _146_ net17 _154_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_52_53 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
Xinput18 io_in[25] net18 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_14_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
Xinput29 io_in[6] net29 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
XFILLER_42_9 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__471__I net36 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_6_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_10_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_65_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__530__CLK clknet_2_0__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_37_227 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_60_274 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_45_282 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_18_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_20_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_33_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_56_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_22_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__496__A2 _076_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_63_30 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_42_252 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_96 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_15_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_2_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_33_5 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_38_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_25_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__411__A2 _235_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_33_274 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_21_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__478__A2 net48 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA_input24_I io_in[30] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__402__A2 net32 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_33_99 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__469__A2 _069_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_66_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_30_200 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_30_222 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_31_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_65_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_53_347 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__396__A1 _202_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__320__A1 _126_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__320__B2 _151_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_115 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_56_163 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_48_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_0_159 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_29_366 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_358 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_491_ net37 _089_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XANTENNA__387__B2 _177_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__387__A1 _188_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_60_53 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_67_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_67_417 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__311__A1 _076_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_47_196 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_47_152 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_50_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_597 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_586 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_575 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_564 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_553 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_542 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_531 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_520 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_483 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_166 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_53_122 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_41_328 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_26_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_49_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA_output55_I net55 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_44_155 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_196 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_474_ net63 _075_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XANTENNA__474__I net63 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_40_383 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__423__B _192_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_269 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_67_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_55_409 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_50_147 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_31_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_58_214 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_58_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_58_236 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_394 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_383 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XPHY_12 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_361 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_372 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XPHY_89 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XANTENNA__294__I net39 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XPHY_78 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_67 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_23 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_45 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_56 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_9_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__293__A3 _065_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_66_96 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_526_ _052_ _020_ clknet_2_3__leaf_wb_clk_i net54 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_60_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__418__B _192_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_17_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_63_5 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_457_ _252_ _026_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_388_ net68 net67 _137_ _217_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand3_1
XFILLER_9_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_13_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__505__A1 net47 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_48_291 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_63_272 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_63_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__328__B _064_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_3_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_11_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_31_191 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__275__A3 _110_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_191 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_180 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_294 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_54_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_36_88 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_52_98 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_52_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_311_ _076_ _152_ _153_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
Xinput19 io_in[26] net19 vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_1
X_509_ _035_ _003_ clknet_2_3__leaf_wb_clk_i net67 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_45_294 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_18_497 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_61_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_43_209 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__414__B1 _071_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_36_294 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_36_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_28_206 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_51_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_24_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_42_297 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_42_231 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__420__A3 _243_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_27_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_8_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_6_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_10_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__482__I _068_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_53_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_18_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_33_297 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_33_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__478__A3 net37 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_56_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA_input17_I io_in[24] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__520__CLK clknet_2_0__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_33_89 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_62_315 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_35_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__477__I net62 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_15_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_7_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_11_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_65_131 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA_input9_I io_in[17] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_334 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_24_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__396__A2 net2 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_38_356 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_0_60 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_21_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_26_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_56_175 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_17_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_28_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_52_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_52_381 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_44_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_490_ net48 _088_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_47_131 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_62_167 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_50_307 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_35_348 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_543 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_532 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_521 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_510 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_598 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_587 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_576 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_565 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_554 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_34_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_5_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__533__RN _027_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_39_66 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_39_55 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_1_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_473_ _073_ net27 _074_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_55_76 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_55_10 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_44_145 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA_output48_I net48 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_40_351 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__490__I net48 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__296__A1 net43 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_67_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_48_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__524__RN _018_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_35_112 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_35_156 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_16_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__515__RN _009_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__287__A1 net55 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_384 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_340 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_351 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_362 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_373 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_395 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XPHY_13 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_24 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_14_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_35 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_46 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_26_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_26_156 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XPHY_79 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_68 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_57 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XANTENNA__278__A1 _073_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_66_53 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_49_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_2_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_456_ _252_ _025_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_525_ _051_ _019_ clknet_2_2__leaf_wb_clk_i net53 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_32_148 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_32_159 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_387_ _188_ _215_ _216_ _106_ _177_ _039_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XANTENNA__505__A2 net46 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__269__A1 net60 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_63_262 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_48_281 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__344__B _172_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__510__D _036_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_46_229 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_192 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_181 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_170 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_273 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_52_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_424 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_310_ net53 _110_ _152_ vdd vss gf180mcu_fd_sc_mcu7t5v0__xor2_1
XFILLER_39_292 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_52_88 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_6_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_10_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_45_251 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__423__A1 _240_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_60_276 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_60_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_439_ _249_ _251_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
X_508_ _034_ _002_ clknet_2_0__leaf_wb_clk_i net66 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_9_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_54_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__414__B2 _238_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__414__A1 _068_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_36_273 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA_clkbuf_2_3__f_wb_clk_i_I clknet_0_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_51_276 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_62_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_59_387 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_66 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_63_98 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_76 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_65_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_44_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_17_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_24_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_20_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_59_140 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_58_87 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_59_195 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_47_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_30_246 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_65_165 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_17_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_61_360 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_349 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_53_327 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_53_316 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_72 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_9_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_21_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__320__A3 _160_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_139 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_28_79 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_60_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_60_99 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_4_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_67_419 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_62_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_62_124 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_43_360 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_7_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_566 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_555 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_58_408 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_544 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_533 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__398__I net68 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_522 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_511 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_500 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_485 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_66_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_599 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_588 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__510__CLK clknet_2_2__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_577 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_38_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_14_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_22_500 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__513__D _039_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_30_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_57_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_44_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_472_ _072_ _073_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
XFILLER_29_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__533__CLK clknet_2_0__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__296__A2 net40 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_48_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_0_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_481 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_63_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_50_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__287__A2 net54 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_396 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_330 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_341 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_352 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_363 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_374 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__508__D _034_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_41_127 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_14 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_25 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_36 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_47 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_26_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_58 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_149 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_22_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_49_205 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__278__A2 net22 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_1_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA_output60_I net60 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_57_282 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_45_422 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_45_444 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_2_29 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_455_ _252_ _024_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_524_ _050_ _018_ clknet_2_0__leaf_wb_clk_i net52 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_45_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_386_ _202_ net4 _216_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_32_127 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__505__A3 net45 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__269__A2 _111_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_55_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_51_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_31_193 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__344__C net36 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_193 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_182 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_171 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_160 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_42_436 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_14_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_45_263 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_33_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_438_ _250_ _009_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_60_266 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_507_ _033_ _001_ clknet_2_1__leaf_wb_clk_i net65 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
X_369_ _072_ _202_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
XFILLER_20_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_47_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_51_288 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_51_266 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_51_255 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_51_211 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__414__A2 _234_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_36_241 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_22_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__521__D _047_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__350__A1 _180_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__405__A2 _104_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_42_200 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_15_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_19_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_27_230 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_255 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_6_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_33_277 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_21_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__399__A1 net67 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__516__D _042_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_33_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_3_137 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_59_152 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_58_99 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_47_336 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_47_303 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_7_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_23_91 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_30_269 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_65_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_53_339 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_369 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_61_383 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_0_95 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__305__A1 _097_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_107 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA_input22_I io_in[29] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_44_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_28_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_12_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_67_409 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_47_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_589 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_578 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_567 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_556 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_545 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_534 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_523 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_512 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_501 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_38_199 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_30_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_39_57 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_39_35 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_133 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_29_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_44_125 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_471_ net36 _072_ vdd vss gf180mcu_fd_sc_mcu7t5v0__inv_1
XFILLER_25_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_67_239 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__499__I net56 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__296__A3 net68 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_4_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_63_423 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_48_497 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_35_136 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__287__A3 net53 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_66_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_58_239 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_397 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_386 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_375 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_320 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_331 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_342 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_353 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_364 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_41_117 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__358__B _192_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XPHY_15 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_26 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_48 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_59 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XANTENNA__524__D _050_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_6_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_1_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_66_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_66_55 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_57_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
X_523_ _049_ _017_ clknet_2_0__leaf_wb_clk_i net51 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XANTENNA_output53_I net53 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_454_ _252_ _023_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_385_ _210_ _214_ _192_ _215_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_40_194 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_9_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__505__A4 net44 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_48_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_63_242 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_36_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_23_139 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_11_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_150 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__519__D _045_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_39_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_183 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_161 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_194 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_264 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__523__CLK clknet_2_0__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_22_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_2_500 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_10_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_7_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_506_ _032_ _000_ clknet_2_1__leaf_wb_clk_i net64 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_45_297 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_45_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_45_231 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_18_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_437_ _250_ _008_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_299_ net54 _142_ net55 _143_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
X_368_ _064_ _200_ _201_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_56_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_3_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_47_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_63_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_223 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_42_289 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_278 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_23_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_6_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_38_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_2_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_33_256 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_33_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_14_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__399__A2 _137_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_33_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__532__D _058_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_20_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_58_45 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_58_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_62_307 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_55_381 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_15_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_30_226 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_7_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_46_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_38_348 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_61_362 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_21_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__305__A2 _142_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_119 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_28_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA_input15_I io_in[22] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__527__D _053_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_44_329 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_44_69 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_60_57 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__536__RN _030_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_62_104 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_156 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_35_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_28_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__480__A1 _076_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_34_91 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__527__RN _021_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__299__A1 net54 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_579 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_568 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_557 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_546 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_535 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_524 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_513 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_502 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA_input7_I io_in[15] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_38_134 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_22_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_26_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__518__RN _012_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_1_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_57_410 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_29_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_52_170 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_44_159 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_40_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_470_ _070_ _071_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
XFILLER_67_207 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__296__A4 net67 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_35_159 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_29_91 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_31_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__287__A4 _110_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_310 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_332 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_39_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_398 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_387 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_376 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_343 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_365 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_34_170 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_16 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_27 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_38 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_22_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XPHY_49 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_26_148 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_522_ _048_ _016_ clknet_2_3__leaf_wb_clk_i net50 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
X_453_ _252_ _022_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_45_402 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_17_137 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA_output46_I net46 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_384_ _104_ _108_ _106_ _214_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai21_1
XFILLER_13_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__371__B1 _105_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_31_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_48_295 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_48_273 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__426__A1 _070_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__426__B2 _177_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_31_140 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_184 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_173 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_162 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_151 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_140 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_287 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_54_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_36_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XTAP_195 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_298 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__535__D _061_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_65_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__408__B2 _177_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__408__A1 _188_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_60_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_436_ _250_ _007_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_505_ net47 net46 net45 net44 _101_ vdd vss gf180mcu_fd_sc_mcu7t5v0__and4_1
X_367_ _105_ _199_ _200_ vdd vss gf180mcu_fd_sc_mcu7t5v0__xor2_1
XFILLER_42_91 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_80 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_493 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_298_ net53 _136_ _137_ _141_ _142_ vdd vss gf180mcu_fd_sc_mcu7t5v0__and4_1
XFILLER_9_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_5_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_36_265 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_22_28 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_32_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_59_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_59_379 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_59_302 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_27_210 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_63_13 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_42_202 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_10_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_33_202 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_18_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_419_ _202_ net29 _243_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_53_90 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_33_224 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_14_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_52_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__513__CLK clknet_2_1__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_52_500 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_20_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_47_349 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_15_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_30_216 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_11_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__536__CLK clknet_2_0__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_2_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_17_5 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_61_330 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_38_338 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_31 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_9_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_56_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_56_102 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_44_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_37_371 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_60_25 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_43_341 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_34_81 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_525 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_514 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__299__A2 _142_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_7_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_66_488 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_569 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_558 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_547 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_536 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_38_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_38_124 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_3_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_15_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_53_138 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_34_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_14_29 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_30_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_26 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_57_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_55_14 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_9_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_473 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_29_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_81 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_63_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_50_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_16_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_300 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_311 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_322 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_333 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_344 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_355 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_366 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_39_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_399 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_388 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_377 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XPHY_17 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_28 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_26_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_34_182 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XPHY_39 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XANTENNA__380__A1 _209_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_1_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_57_241 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_452_ _252_ _021_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_521_ _047_ _015_ clknet_2_3__leaf_wb_clk_i net49 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
X_383_ _188_ _212_ _213_ _209_ _177_ _040_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_45_436 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA_output39_I net39 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_32_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__371__A1 _188_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__371__B2 _151_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_40_163 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_40_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xoutput60 net60 io_out[30] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_31_93 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_48_285 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_48_230 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_51_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_8_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__362__A1 _190_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__417__A2 _240_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_185 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_174 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_163 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_152 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_196 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XANTENNA__385__B _192_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_39_263 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_14_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_27_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_52_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_6_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_10_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__404__I net67 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_60_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_435_ _250_ _006_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XANTENNA_clkbuf_2_0__f_wb_clk_i_I clknet_0_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_45_266 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_366_ net42 net41 net40 _198_ _199_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand4_2
XFILLER_33_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_13_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_504_ net51 net50 _100_ vdd vss gf180mcu_fd_sc_mcu7t5v0__and2_1
X_297_ _138_ _139_ _107_ _140_ _141_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor4_2
XANTENNA__314__I net52 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_3_53 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_51_203 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_233 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_36_211 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_51_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_22_18 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__335__A1 net49 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_42_269 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_42_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_15_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XANTENNA__326__A1 _126_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__326__B2 _151_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_2_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_53_80 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_349_ _183_ _184_ _185_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
X_418_ _235_ _241_ _192_ _242_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_45_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_56_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_64_372 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_24_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_32_291 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_59_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_59_155 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_317 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_48_91 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_38_306 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_0_10 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_46_361 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_87 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__502__I net53 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_37_361 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_25_501 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_60_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_20_250 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_43_353 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_11_283 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_548 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_537 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_526 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_515 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_504 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_559 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_19_350 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_61_161 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_61_150 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_30_29 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_57_401 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA_input20_I io_in[27] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_55_26 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__526__CLK clknet_2_3__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_40_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_40_312 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_67_209 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_63_415 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_48_456 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_35_128 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_0_485 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_28_191 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_401 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_378 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_301 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_312 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_323 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_334 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_345 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_356 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_367 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_41_109 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_18 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_29 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_22_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_66_25 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_57_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_57_231 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
X_520_ _046_ _014_ clknet_2_0__leaf_wb_clk_i net47 vdd vss gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_49_209 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_451_ _252_ _020_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_382_ _202_ net5 _213_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_53_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_45_448 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_15_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_25_161 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_25_183 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_31_50 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xoutput50 net50 io_out[21] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_49_9 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_0_282 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
Xoutput61 net61 io_out[31] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_63_256 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_63_234 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_63_223 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_63_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_48_242 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_16_172 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_59_507 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_286 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_39_231 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XTAP_186 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_175 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_164 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_153 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_142 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_197 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_289 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_35_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_50_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA__408__A3 _233_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_45_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_45_223 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_503_ _095_ _096_ _097_ _098_ _099_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor4_4
XANTENNA_output51_I net51 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_434_ _250_ _005_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
X_296_ net43 net40 net68 net67 _140_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand4_1
X_365_ _104_ _108_ _198_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XANTENNA__344__A2 _180_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__330__I net50 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_3_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_51_259 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_51_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_36_289 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_36_245 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_17_492 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__335__A2 _172_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_32_495 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_59_315 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__271__A1 _073_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_27_201 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_223 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_27_234 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_63_26 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_10_101 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__415__I net65 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_6_105 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_5_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_58_392 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__262__A1 net58 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_37_93 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_33_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_53_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_417_ _239_ _240_ _241_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
X_348_ net45 net44 _179_ _184_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand3_1
X_279_ _071_ _124_ _125_ _121_ _082_ _056_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_38_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_64_340 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__253__A1 net52 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_58_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_55_340 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_15_215 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_7_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_11_421 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_23_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_48_81 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_46_340 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_38_318 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_44 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__483__B2 _082_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__483__A1 _071_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_61_365 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_61_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
Xcntr_example_70 io_out[33] vdd vss gf180mcu_fd_sc_mcu7t5v0__tiel
XFILLER_56_159 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_52_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_47_115 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__465__A1 net63 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_43_310 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_549 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_538 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_527 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_516 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_505 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_66_479 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_38_104 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_34_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_57_424 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_39_39 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_39_28 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_52_162 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_44_129 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA_input13_I io_in[20] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_25_354 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__383__B1 _209_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_4_247 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_453 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_16_321 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_61_70 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_43_173 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_31_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_61_92 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_61_81 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_6_21 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XANTENNA_input5_I io_in[13] vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_66_243 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_379 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_20_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XTAP_302 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_313 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_324 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_335 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_346 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_368 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_62_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_19 vdd vss gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_41_29 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_10_508 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_66_37 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_450_ _249_ _252_ vdd vss gf180mcu_fd_sc_mcu7t5v0__buf_2
X_381_ _205_ _211_ _192_ _212_ vdd vss gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_40_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_40_132 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_13_357 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_15_41 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_40_198 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_31_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xoutput40 net40 io_out[12] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
Xoutput51 net51 io_out[22] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
Xoutput62 net62 io_out[3] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_63_268 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_31_187 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__516__CLK clknet_2_1__leaf_wb_clk_i vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XTAP_187 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_165 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_154 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_143 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_198 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_54_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_54_268 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_54_246 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_50_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_22_176 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA_output44_I net44 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_433_ _250_ _004_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_45_235 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_502_ net53 _098_ vdd vss gf180mcu_fd_sc_mcu7t5v0__inv_1
XFILLER_26_460 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
X_295_ net38 _139_ vdd vss gf180mcu_fd_sc_mcu7t5v0__inv_1
XFILLER_42_72 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_50 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_41_485 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_364_ _188_ _196_ _197_ _170_ _151_ _043_ vdd vss gf180mcu_fd_sc_mcu7t5v0__oai32_1
XFILLER_67_80 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_44_290 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_32_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XANTENNA__271__A2 net24 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_42_227 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_42_205 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_279 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_50_282 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__326__A3 _165_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_23_496 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__431__I _250_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_10_179 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_2_389 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__262__A2 net57 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_14_463 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_416_ _065_ _103_ _240_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
X_347_ net46 _183_ vdd vss gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_41_271 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_278_ _073_ net22 _125_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_52_5 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XANTENNA__341__I net47 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_64_352 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__253__A2 net49 vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_32_282 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_59_124 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_47_319 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_55_363 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_55_352 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_11_499 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_46_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_34_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_0_12 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_34 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_21_208 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_50_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xcntr_example_71 io_out[34] vdd vss gf180mcu_fd_sc_mcu7t5v0__tiel
XFILLER_44_29 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_37_352 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_62_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_55_160 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_16_503 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__465__A2 _065_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_34_95 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_28_385 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_7_212 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_539 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_528 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_517 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_506 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_61_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_46_182 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_61_196 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__392__A1 _202_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_39_18 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_57_403 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_44_119 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_44_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_52_174 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XANTENNA__383__A1 _188_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XANTENNA__383__B2 _177_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_0_410 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_63_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_45_61 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_43_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_73 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_6_33 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_303 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_39_425 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_13_2 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XTAP_325 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_26_108 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XTAP_336 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_347 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_358 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_369 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_22_314 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XANTENNA__365__A1 _104_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
XFILLER_45_428 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_45_406 vdd vss gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_25_141 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XANTENNA__434__I _250_ vdd vss gf180mcu_fd_sc_mcu7t5v0__antenna
X_380_ _209_ _210_ _211_ vdd vss gf180mcu_fd_sc_mcu7t5v0__nand2_1
XFILLER_40_155 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_25_196 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xoutput52 net52 io_out[23] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
Xoutput41 net41 io_out[13] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_48_244 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_251 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
Xoutput63 net63 io_out[4] vdd vss gf180mcu_fd_sc_mcu7t5v0__clkbuf_4
XFILLER_48_299 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_31_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_166 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_155 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_144 vdd vss gf180mcu_fd_sc_mcu7t5v0__filltie
.ends
